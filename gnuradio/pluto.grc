options:
  parameters:
    generate_options: qt_gui
    id: pluto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '5'
    value: '1'
  states: {}
- name: lo
  id: variable_qtgui_range
  parameters:
    label: lo
    start: 450e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx_gain
    start: '0'
    step: '1'
    stop: '70'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.084e6)
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    label: tone_freq
    start: '0'
    step: 1e3
    stop: 100e3
    value: 10e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(lo)
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(lo)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [iio_pluto_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
